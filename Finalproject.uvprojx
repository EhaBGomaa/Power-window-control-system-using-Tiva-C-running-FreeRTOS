# Keil uVision project Finalproject.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Finalproject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\ti\tivaware_c_series_2_1_4_178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: -entry Reset_Handler
  group Src
    ./: buttons.h main.c
    C:/Users/Ehab/Desktop/MCTA/Term 8/Embedded2/RTOS-Project-main (2)/RTOS-Project-main/: TivaWare
  group Library
    C:/Users/Ehab/Desktop/MCTA/Term 8/Embedded2/RTOS-Project-main (2)/RTOS-Project-main/TivaWare/driverlib/: rvmdk
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
